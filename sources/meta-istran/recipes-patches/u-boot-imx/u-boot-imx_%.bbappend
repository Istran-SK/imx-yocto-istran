FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"

SRC_URI += " \
    file://0001-dm421-fix-Kconfig-include-for-U-Boot-2024.04.patch \
"
