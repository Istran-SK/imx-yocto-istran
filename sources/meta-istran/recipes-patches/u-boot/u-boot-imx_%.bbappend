FILESEXTRAPATHS:prepend := "${THISDIR}/patches:"

SRC_URI:append:dm421 = " \
    file://0001-Add-dm421.patch \
"
