FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0002-original-patch-0001-imx-mkimage.patch.patch"

