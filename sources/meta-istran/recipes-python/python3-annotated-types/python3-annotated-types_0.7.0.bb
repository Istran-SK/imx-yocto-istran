SUMMARY = "annotated-types (prebuilt wheel)"
LICENSE = "CLOSED"
inherit python_wheel
SRC_URI = "file://${PY_WHEEL_FILE};unpack=0"
PY_WHEEL_FILE = "annotated_types-0.7.0-py3-none-any.whl"
