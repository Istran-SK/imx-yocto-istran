SUMMARY = "sniffio (prebuilt wheel)"
LICENSE = "CLOSED"
inherit python_wheel
SRC_URI = "file://${PY_WHEEL_FILE};unpack=0"
PY_WHEEL_FILE = "sniffio-1.3.1-py3-none-any.whl"
